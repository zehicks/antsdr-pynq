options:
  parameters:
    generate_options: qt_gui
    id: fm_rx
    output_language: python
    title: fm_rx
  states: {}

blocks:
- name: M1
  id: variable
  parameters:
    value: '5'
  states: {}
- name: M2
  id: variable
  parameters:
    value: '8'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: int(88.1e6)
    step: 200e3
    stop: int(108.1e6)
    value: int(89.7e6)
  states: {}
- name: fm_dev_hz
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1.92e6)
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: samp_rate/(M1*M2)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/hicksze1/broadcast_fm_1.92MHz.fc32
    type: complex
  states: {state: disabled}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: samp_rate*10
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: 2**16
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(500e3)
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.99
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Pluto TX
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://192.168.2.99:5050
    timeout: '100'
    type: float
  states: {state: disabled}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_add_xx_0, '1']
- [iio_pluto_source_0, '0', blocks_complex_to_imag_0, '0']
- [iio_pluto_source_0, '0', blocks_complex_to_real_0, '0']
- [iio_pluto_source_0, '0', blocks_head_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [zeromq_sub_source_0, '0', analog_fm_deemph_0, '0']
- [zeromq_sub_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
